v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 390 -730 1190 -330 {flags=graph
y1=0
y2=1.9
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1e-12
x2=1e-07
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node=nand_out
color=12
dataset=-1
unitx=1
logx=0
logy=0
}
N 320 90 410 90 {
lab=#net1}
N 490 90 530 90 {
lab=#net2}
N 530 90 530 110 {
lab=#net2}
N 530 110 570 110 {
lab=#net2}
N 750 90 840 90 {
lab=#net3}
N 920 90 960 90 {
lab=#net4}
N 960 90 960 110 {
lab=#net4}
N 960 110 1000 110 {
lab=#net4}
N 1180 90 1270 90 {
lab=#net5}
N 1350 90 1390 90 {
lab=#net6}
N 1390 90 1390 110 {
lab=#net6}
N 1390 110 1430 110 {
lab=#net6}
N 1610 90 1700 90 {
lab=#net7}
N 1780 90 1820 90 {
lab=#net8}
N 1820 90 1820 110 {
lab=#net8}
N 1820 110 1860 110 {
lab=#net8}
N 2040 90 2130 90 {
lab=#net9}
N 2210 90 2250 90 {
lab=#net10}
N 2250 90 2250 110 {
lab=#net10}
N 2250 110 2290 110 {
lab=#net10}
N 2470 90 2560 90 {
lab=#net11}
N 2640 90 2680 90 {
lab=#net12}
N 2680 90 2680 110 {
lab=#net12}
N 2680 110 2720 110 {
lab=#net12}
N 2900 90 2990 90 {
lab=#net13}
N 3070 90 3110 90 {
lab=#net14}
N 3110 90 3110 110 {
lab=#net14}
N 3110 110 3150 110 {
lab=#net14}
N 3330 90 3420 90 {
lab=#net15}
N 3500 90 3540 90 {
lab=#net16}
N 3540 90 3540 110 {
lab=#net16}
N 3540 110 3580 110 {
lab=#net16}
N 3560 350 3580 350 {
lab=VSS}
N 3560 330 3560 350 {
lab=VSS}
N 3560 330 3580 330 {
lab=VSS}
N 3760 330 3800 330 {
lab=#net17}
N 3500 270 3750 270 {
lab=#net18}
N 3560 90 3580 90 {
lab=#net18}
N 3560 90 3560 270 {
lab=#net18}
N 3130 90 3150 90 {
lab=#net19}
N 3130 90 3130 270 {
lab=#net19}
N 3070 270 3420 270 {
lab=#net19}
N 2700 90 2720 90 {
lab=#net20}
N 2700 90 2700 270 {
lab=#net20}
N 2640 270 2990 270 {
lab=#net20}
N 2270 90 2290 90 {
lab=#net21}
N 2270 90 2270 270 {
lab=#net21}
N 2210 270 2560 270 {
lab=#net21}
N 1840 90 1860 90 {
lab=#net22}
N 1840 90 1840 270 {
lab=#net22}
N 1780 270 2130 270 {
lab=#net22}
N 1410 90 1430 90 {
lab=#net23}
N 1410 90 1410 270 {
lab=#net23}
N 1350 270 1700 270 {
lab=#net23}
N 980 90 1000 90 {
lab=#net24}
N 980 90 980 270 {
lab=#net24}
N 920 270 1270 270 {
lab=#net24}
N 550 90 570 90 {
lab=#net25}
N 550 90 550 270 {
lab=#net25}
N 490 270 840 270 {
lab=#net25}
N 120 90 140 90 {
lab=#net26}
N 120 90 120 270 {
lab=#net26}
N 120 270 410 270 {
lab=#net26}
N 80 150 140 150 {
lab=reset}
N 80 130 140 130 {
lab=VCC}
N 510 150 570 150 {
lab=VCC}
N 510 130 570 130 {
lab=reset}
N 940 150 1000 150 {
lab=VCC}
N 940 130 1000 130 {
lab=reset}
N 1370 150 1430 150 {
lab=VCC}
N 1370 130 1430 130 {
lab=reset}
N 1800 150 1860 150 {
lab=VCC}
N 1800 130 1860 130 {
lab=reset}
N 2230 150 2290 150 {
lab=VCC}
N 2230 130 2290 130 {
lab=reset}
N 2660 150 2720 150 {
lab=VCC}
N 2660 130 2720 130 {
lab=reset}
N 3090 150 3150 150 {
lab=VCC}
N 3090 130 3150 130 {
lab=reset}
N 3520 150 3580 150 {
lab=VCC}
N 3520 130 3580 130 {
lab=reset}
N 3520 370 3580 370 {
lab=reset}
N 3090 370 3150 370 {
lab=reset}
N 3120 430 3800 430 {
lab=#net17}
N 3120 330 3150 330 {
lab=#net17}
N 3090 350 3150 350 {
lab=comp_in}
N 3330 330 3370 330 {
lab=#net27}
N 2660 370 2720 370 {
lab=reset}
N 2660 350 2720 350 {
lab=comp_in}
N 3370 330 3370 450 {
lab=#net27}
N 2690 330 2720 330 {
lab=#net27}
N 2690 330 2690 450 {
lab=#net27}
N 3800 330 3800 430 {
lab=#net17}
N 3120 330 3120 430 {
lab=#net17}
N 2690 450 3370 450 {
lab=#net27}
N 2900 330 2940 330 {
lab=#net28}
N 2230 370 2290 370 {
lab=reset}
N 2230 350 2290 350 {
lab=comp_in}
N 2940 330 2940 430 {
lab=#net28}
N 2270 430 2940 430 {
lab=#net28}
N 2270 330 2270 430 {
lab=#net28}
N 2270 330 2290 330 {
lab=#net28}
N 2470 330 2500 330 {
lab=#net29}
N 2500 330 2500 450 {
lab=#net29}
N 1800 370 1860 370 {
lab=reset}
N 1800 350 1860 350 {
lab=comp_in}
N 1370 370 1430 370 {
lab=reset}
N 1370 350 1430 350 {
lab=comp_in}
N 940 370 1000 370 {
lab=reset}
N 940 350 1000 350 {
lab=comp_in}
N 510 370 570 370 {
lab=reset}
N 510 350 570 350 {
lab=comp_in}
N 80 370 140 370 {
lab=reset}
N 80 350 140 350 {
lab=comp_in}
N 1830 330 1860 330 {
lab=#net29}
N 1830 330 1830 450 {
lab=#net29}
N 1830 450 2500 450 {
lab=#net29}
N 2040 330 2080 330 {
lab=#net30}
N 2080 330 2080 430 {
lab=#net30}
N 1410 430 2080 430 {
lab=#net30}
N 1410 330 1410 430 {
lab=#net30}
N 1410 330 1430 330 {
lab=#net30}
N 1610 330 1640 330 {
lab=#net31}
N 1640 330 1640 450 {
lab=#net31}
N 970 330 1000 330 {
lab=#net31}
N 970 330 970 450 {
lab=#net31}
N 970 450 1640 450 {
lab=#net31}
N 1180 330 1220 330 {
lab=#net32}
N 1220 330 1220 430 {
lab=#net32}
N 550 430 1220 430 {
lab=#net32}
N 550 330 550 430 {
lab=#net32}
N 550 330 570 330 {
lab=#net32}
N 750 330 780 330 {
lab=#net33}
N 780 330 780 450 {
lab=#net33}
N 110 330 140 330 {
lab=#net33}
N 110 330 110 450 {
lab=#net33}
N 110 450 780 450 {
lab=#net33}
N 80 390 140 390 {
lab=q_n9}
N 510 390 570 390 {
lab=q_n8}
N 940 390 1000 390 {
lab=q_n7}
N 1370 390 1430 390 {
lab=q_n6}
N 1800 390 1860 390 {
lab=q_n5}
N 2230 390 2290 390 {
lab=q_n4}
N 2660 390 2720 390 {
lab=q_n3}
N 3090 390 3150 390 {
lab=q_n2}
N 80 110 140 110 {
lab=VCC}
C {devices/vsource.sym} -90 -190 0 0 {name=V1 value="pwl
+0n 0
+25n 0 
+25.2n 1.8"}
C {devices/vsource.sym} -90 -330 0 0 {name=V2 value="pwl
+0n 0
+50n 0 
+50.2n 1.8"}
C {devices/vsource.sym} -220 -260 0 0 {name=V3 value="pwl
+0n 0
+75n 0 
+75.2n 1.8"}
C {devices/code_shown.sym} -520 -910 0 0 {name=s1 only_toplevel=true value="
.options acct list
.temp 25
.control
  save all
  savecurrents
  op
  write sar.raw
  reset
  set appendwrite
  save all
  tran 0.1n 100n uic
  write sar.raw
  reset
  quit 0
.endc"
}
C {devices/lab_wire.sym} -90 -360 0 0 {name=p1 sig_type=std_logic lab=B}
C {devices/lab_wire.sym} -90 -220 0 0 {name=p2 sig_type=std_logic lab=A}
C {devices/lab_wire.sym} -220 -290 0 0 {name=p3 sig_type=std_logic lab=C}
C {devices/gnd.sym} -220 -230 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} -90 -160 0 0 {name=l2 lab=GND}
C {devices/gnd.sym} -90 -300 0 0 {name=l3 lab=GND}
C {devices/launcher.sym} 440 -300 0 0 {name=h5
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/sar.raw tran"
}
C {devices/vsource.sym} -230 -520 0 0 {name=V4 value=1.8}
C {devices/gnd.sym} -230 -490 0 0 {name=l4 lab=GND}
C {devices/lab_wire.sym} -230 -550 0 0 {name=p8 sig_type=std_logic lab=VPWR}
C {devices/vsource.sym} -100 -520 0 0 {name=V5 value=1.8}
C {devices/gnd.sym} -100 -490 0 0 {name=l5 lab=GND}
C {devices/lab_wire.sym} -100 -550 0 0 {name=p9 sig_type=std_logic lab=VPB}
C {devices/vsource.sym} 10 -520 0 0 {name=V6 value=0}
C {devices/gnd.sym} 10 -490 0 0 {name=l6 lab=GND}
C {devices/lab_wire.sym} 10 -550 0 0 {name=p10 sig_type=std_logic lab=VNB}
C {devices/vsource.sym} 90 -520 0 0 {name=V7 value=0}
C {devices/gnd.sym} 90 -490 0 0 {name=l7 lab=GND}
C {devices/lab_wire.sym} 90 -550 0 0 {name=p11 sig_type=std_logic lab=VGND}
C {devices/code.sym} 200 -1070 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {sky130_stdcells/dfbbp_1.sym} 230 120 0 0 {name=x2 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 450 90 0 0 {name=x3 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfbbp_1.sym} 660 120 0 0 {name=x4 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 880 90 0 0 {name=x5 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfbbp_1.sym} 1090 120 0 0 {name=x6 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1310 90 0 0 {name=x7 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfbbp_1.sym} 1520 120 0 0 {name=x8 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1740 90 0 0 {name=x9 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfbbp_1.sym} 1950 120 0 0 {name=x10 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 2170 90 0 0 {name=x11 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfbbp_1.sym} 2380 120 0 0 {name=x12 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 2600 90 0 0 {name=x13 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfbbp_1.sym} 2810 120 0 0 {name=x14 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 3030 90 0 0 {name=x15 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfbbp_1.sym} 3240 120 0 0 {name=x16 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 3460 90 0 0 {name=x17 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfbbp_1.sym} 3670 120 0 0 {name=x18 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfbbp_1.sym} 3670 360 0 0 {name=x19 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 3760 110 0 1 {name=p12 sig_type=std_logic lab=q_n1}
C {devices/lab_wire.sym} 3580 390 0 0 {name=p13 sig_type=std_logic lab=q_n}
C {devices/lab_wire.sym} 3560 330 0 0 {name=p14 sig_type=std_logic lab=VSS}
C {sky130_stdcells/buf_1.sym} 3460 270 0 1 {name=x20 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 3790 270 0 1 {name=x21 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 3030 270 0 1 {name=x22 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 2600 270 0 1 {name=x23 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 2170 270 0 1 {name=x24 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1740 270 0 1 {name=x25 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 1310 270 0 1 {name=x26 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 880 270 0 1 {name=x27 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 450 270 0 1 {name=x28 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 80 130 0 0 {name=p15 sig_type=std_logic lab=VCC}
C {devices/lab_wire.sym} 80 150 0 0 {name=p16 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 510 150 0 0 {name=p17 sig_type=std_logic lab=VCC}
C {devices/lab_wire.sym} 510 130 0 0 {name=p18 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 940 150 0 0 {name=p19 sig_type=std_logic lab=VCC}
C {devices/lab_wire.sym} 940 130 0 0 {name=p20 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 1370 150 0 0 {name=p21 sig_type=std_logic lab=VCC}
C {devices/lab_wire.sym} 1370 130 0 0 {name=p22 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 1800 150 0 0 {name=p23 sig_type=std_logic lab=VCC}
C {devices/lab_wire.sym} 1800 130 0 0 {name=p24 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 2230 150 0 0 {name=p25 sig_type=std_logic lab=VCC}
C {devices/lab_wire.sym} 2230 130 0 0 {name=p26 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 2660 150 0 0 {name=p27 sig_type=std_logic lab=VCC}
C {devices/lab_wire.sym} 2660 130 0 0 {name=p28 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 3090 150 0 0 {name=p29 sig_type=std_logic lab=VCC}
C {devices/lab_wire.sym} 3090 130 0 0 {name=p30 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 3520 150 0 0 {name=p31 sig_type=std_logic lab=VCC}
C {devices/lab_wire.sym} 3520 130 0 0 {name=p32 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 3330 110 0 1 {name=p33 sig_type=std_logic lab=q_n2}
C {devices/lab_wire.sym} 2900 110 0 1 {name=p34 sig_type=std_logic lab=q_n3}
C {devices/opin.sym} -430 -80 0 0 {name=p35 lab=b7}
C {devices/lab_wire.sym} -430 -80 0 0 {name=p36 sig_type=std_logic lab=b7}
C {devices/opin.sym} -430 -120 0 0 {name=p37 lab=b6}
C {devices/lab_wire.sym} -430 -120 0 0 {name=p38 sig_type=std_logic lab=b6}
C {devices/opin.sym} -430 -160 0 0 {name=p39 lab=b5}
C {devices/lab_wire.sym} -430 -160 0 0 {name=p40 sig_type=std_logic lab=b5}
C {devices/opin.sym} -430 -200 0 0 {name=p41 lab=b4}
C {devices/lab_wire.sym} -430 -200 0 0 {name=p42 sig_type=std_logic lab=b4}
C {devices/opin.sym} -430 -240 0 0 {name=p43 lab=b3}
C {devices/lab_wire.sym} -430 -240 0 0 {name=p44 sig_type=std_logic lab=b3}
C {devices/opin.sym} -430 -280 0 0 {name=p45 lab=b2}
C {devices/lab_wire.sym} -430 -280 0 0 {name=p46 sig_type=std_logic lab=b2}
C {devices/opin.sym} -430 -320 0 0 {name=p47 lab=b1}
C {devices/lab_wire.sym} -430 -320 0 0 {name=p48 sig_type=std_logic lab=b1}
C {devices/opin.sym} -430 -360 0 0 {name=p49 lab=b0}
C {devices/lab_wire.sym} -430 -360 0 0 {name=p50 sig_type=std_logic lab=b0}
C {devices/lab_wire.sym} 3830 270 0 1 {name=p51 sig_type=std_logic lab=clk_in}
C {devices/lab_wire.sym} 2470 110 0 1 {name=p52 sig_type=std_logic lab=q_n4}
C {devices/lab_wire.sym} 2040 110 0 1 {name=p53 sig_type=std_logic lab=q_n5}
C {devices/lab_wire.sym} 1610 110 0 1 {name=p54 sig_type=std_logic lab=q_n6}
C {devices/lab_wire.sym} 1180 110 0 1 {name=p55 sig_type=std_logic lab=q_n7}
C {devices/lab_wire.sym} 750 110 0 1 {name=p56 sig_type=std_logic lab=q_n8}
C {devices/lab_wire.sym} 320 110 0 1 {name=p57 sig_type=std_logic lab=q_n9}
C {sky130_stdcells/dfbbp_1.sym} 3240 360 0 0 {name=x29 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 3520 370 0 0 {name=p58 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 3090 370 0 0 {name=p59 sig_type=std_logic lab=reset}
C {devices/ipin.sym} -410 -450 0 0 {name=p60 lab=comp_in}
C {devices/ipin.sym} -410 -420 0 0 {name=p61 lab=clk_in}
C {devices/ipin.sym} -410 -480 0 0 {name=p62 lab=reset_in}
C {devices/ipin.sym} -410 -510 0 0 {name=p63 lab=VCC}
C {devices/ipin.sym} -410 -540 0 0 {name=p64 lab=VSS}
C {devices/lab_wire.sym} -410 -540 0 1 {name=p65 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -410 -510 0 1 {name=p66 sig_type=std_logic lab=VCC}
C {devices/lab_wire.sym} -410 -480 0 1 {name=p67 sig_type=std_logic lab=reset_in
}
C {devices/lab_wire.sym} -410 -450 0 1 {name=p68 sig_type=std_logic lab=comp_in
}
C {devices/lab_wire.sym} -410 -420 0 1 {name=p69 sig_type=std_logic lab=clk_in

}
C {devices/lab_wire.sym} 3090 350 0 0 {name=p70 sig_type=std_logic lab=comp_in
}
C {sky130_stdcells/dfbbp_1.sym} 2810 360 0 0 {name=x30 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 2660 370 0 0 {name=p71 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 2660 350 0 0 {name=p72 sig_type=std_logic lab=comp_in
}
C {sky130_stdcells/dfbbp_1.sym} 2380 360 0 0 {name=x31 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 2230 370 0 0 {name=p73 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 2230 350 0 0 {name=p74 sig_type=std_logic lab=comp_in
}
C {sky130_stdcells/dfbbp_1.sym} 1950 360 0 0 {name=x32 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 1800 370 0 0 {name=p75 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 1800 350 0 0 {name=p76 sig_type=std_logic lab=comp_in
}
C {sky130_stdcells/dfbbp_1.sym} 1520 360 0 0 {name=x33 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 1370 370 0 0 {name=p77 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 1370 350 0 0 {name=p78 sig_type=std_logic lab=comp_in
}
C {sky130_stdcells/dfbbp_1.sym} 1090 360 0 0 {name=x34 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 940 370 0 0 {name=p79 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 940 350 0 0 {name=p80 sig_type=std_logic lab=comp_in
}
C {sky130_stdcells/dfbbp_1.sym} 660 360 0 0 {name=x35 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 510 370 0 0 {name=p81 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 510 350 0 0 {name=p82 sig_type=std_logic lab=comp_in
}
C {sky130_stdcells/dfbbp_1.sym} 230 360 0 0 {name=x36 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 80 370 0 0 {name=p83 sig_type=std_logic lab=reset}
C {devices/lab_wire.sym} 80 350 0 0 {name=p84 sig_type=std_logic lab=comp_in
}
C {devices/lab_wire.sym} 80 390 0 0 {name=p85 sig_type=std_logic lab=q_n9}
C {devices/lab_wire.sym} 3090 390 0 0 {name=p86 sig_type=std_logic lab=q_n2}
C {devices/lab_wire.sym} 2660 390 0 0 {name=p87 sig_type=std_logic lab=q_n3}
C {devices/lab_wire.sym} 2230 390 0 0 {name=p88 sig_type=std_logic lab=q_n4}
C {devices/lab_wire.sym} 1800 390 0 0 {name=p89 sig_type=std_logic lab=q_n5}
C {devices/lab_wire.sym} 1370 390 0 0 {name=p90 sig_type=std_logic lab=q_n6}
C {devices/lab_wire.sym} 940 390 0 0 {name=p91 sig_type=std_logic lab=q_n7}
C {devices/lab_wire.sym} 510 390 0 0 {name=p92 sig_type=std_logic lab=q_n8}
C {devices/lab_wire.sym} 320 330 0 1 {name=p93 sig_type=std_logic lab=b0}
C {devices/lab_wire.sym} 780 330 0 1 {name=p94 sig_type=std_logic lab=b1}
C {devices/lab_wire.sym} 1220 330 0 1 {name=p95 sig_type=std_logic lab=b2}
C {devices/lab_wire.sym} 1640 330 0 1 {name=p96 sig_type=std_logic lab=b3
}
C {devices/lab_wire.sym} 2080 330 0 1 {name=p97 sig_type=std_logic lab=b4
}
C {devices/lab_wire.sym} 2500 330 0 1 {name=p98 sig_type=std_logic lab=b5
}
C {devices/lab_wire.sym} 2940 330 0 1 {name=p99 sig_type=std_logic lab=b6
}
C {devices/lab_wire.sym} 3370 330 0 1 {name=p100 sig_type=std_logic lab=b7
}
C {devices/lab_wire.sym} 80 110 0 0 {name=p101 sig_type=std_logic lab=VSS}
